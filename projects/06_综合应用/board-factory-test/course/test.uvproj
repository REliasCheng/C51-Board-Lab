# Keil uVision project test.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\bsp;.\bsp\leds
  group user
    ./user/: main.c stc89c52rc_it.c
  group bsp
    ./bsp/keys/: keys.c
    ./bsp/leds/: leds.c
    ./bsp/segs/: segs.c
    ./bsp/timer/: timer.c
    ./bsp/: bsp_config.c
    ./bsp/xpt2046/: xpt2046.c
    ./bsp/ds1302/: ds1302.c
    ./bsp/pwm/: pwm.c
    ./bsp/iic/: iic.c
    ./bsp/24c02/: 24c02.c
    ./bsp/lcd1602/: lcd1602.c
    ./bsp/lcd12864/: lcd12864.c
    ./bsp/ds18b20/: ds18b20.c
  group config
    ./user/: config.h
    ./bsp/: bsp_config.h
